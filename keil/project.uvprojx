# Keil uVision project project.uvprojx, settings and files
target project (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MSPM0G3507__
  c include: ..\Core\inc;..\Driver;..\Driver\CMSIS\Core\Include;..\Core\OLED;..\..\..\..\mspm0_sdk_1_20_01_06\source\third_party\CMSIS\Core\Include;..\..\..\..\mspm0_sdk_1_20_01_06\source\third_party\CMSIS\DSP\Include;..\..\..\..\mspm0_sdk_1_20_01_06\source;..\Core\arm_math;..\Driver\ti\driverlib\m0p\sysctl;..\Driver\ti\driverlib\m0p;..\Driver\ti\driverlib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group Core
    ../Core/src/: main.c ti_msp_dl_config.c key.c
    ../: project.syscfg
    ./: startup_mspm0g3507_uvision.s
    ../Core/OLED/: oled_spi.c
  group Driver
    ../Driver/ti/driverlib/: dl_adc12.c dl_aes.c dl_common.c dl_crc.c dl_dac12.c dl_dma.c dl_flashctl.c dl_i2c.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc.c dl_spi.c dl_timer.c dl_trng.c dl_uart.c dl_vref.c
    ../Driver/ti/driverlib/m0p/: dl_interrupt.c
    ../Driver/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0g1x0x_g3x0x.c
  group Dsplib
    ../Core/arm_math/: arm_cortexM0l_math.a
